## drivers/power/pmlog/Kconfig
```kconfig
menuconfig LENOVO_PM_LOG
	bool "Lenovo power management log"
	help
	  Say Y to enable log
```
